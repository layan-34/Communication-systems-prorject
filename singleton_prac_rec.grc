options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ac
  id: variable
  parameters:
    value: '1'
  states: {}
- name: Am
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: fm
  id: variable
  parameters:
    value: '440'
  states: {}
- name: k
  id: variable
  parameters:
    value: 1/Am
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n \n \nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block Envelope Detector \"\"\"\n \n    def __init__(self, threshold=0.0, mode=0, coeff=0.15):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Envelope Detector',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n \n        self.ry = 0\n        self.threshold = threshold\n        self.mode = mode\n        self.coeff = coeff\n \n    def work(self, input_items, output_items):\n        \"\"\"Envelope Detect with Half/Full Wave Rectifier\"\"\"\n        buf = [0] * len(output_items[0])\n        a0 = self.coeff\n        b1 = 1 - a0\n        # Rectify the signal. Mode 0 is half-wave, Mode 1 is full-wave\n        for i in range (0, len(input_items[0])) :\n            if self.mode == 1:\n                buf[i] = abs(input_items[0][i])\n            else:\n                if input_items[0][i] > self.threshold:\n                    buf[i] = input_items[0][i]\n                else:\n                    buf[i] = 0\n        # Simulate simple RC filter with a variable decay coefficient\n        for i in range(0, len(output_items[0])):\n            if i==0:\n                output_items[0][i] = a0*buf[i] + b1*self.ry\n            else:\n                output_items[0][i] = a0*buf[i] + b1*output_items[0][i-1]\n \n        i = len(output_items[0])-1\n        self.ry = output_items[0][i]\n \n        return len(output_items[0])"
    coeff: '0.15'
    mode: '1'
    threshold: '0.5'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2*fm
    decim: '1'
    gain: '1'
    interp: '4'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [epy_block_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', epy_block_0, '0']
- [low_pass_filter_0, '0', audio_sink_1, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
